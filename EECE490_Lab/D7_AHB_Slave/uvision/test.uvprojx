# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe #L --vhx --8x1 --output test.hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: D:\OneDrive\OneDrive - Singapore University of Technology and Design\SUTD_Study\Y3T6-GEXP\EECE490_Embedded_SOC\EECE490E_Lab\D07_Q_project_AHB_Slave\software\common\retarget;D:\OneDrive\OneDrive - Singapore University of Technology and Design\SUTD_Study\Y3T6-GEXP\EECE490_Embedded_SOC\EECE490E_Lab\D07_Q_project_AHB_Slave\software\cmsis\CMSIS\Include;D:\OneDrive\OneDrive - Singapore University of Technology and Design\SUTD_Study\Y3T6-GEXP\EECE490_Embedded_SOC\EECE490E_Lab\D07_Q_project_AHB_Slave\software\cmsis\Device\ARM\CMSDK_CM0\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    D:/OneDrive/OneDrive - Singapore University of Technology and Design/SUTD_Study/Y3T6-GEXP/EECE490_Embedded_SOC/EECE490E_Lab/D07_Q_project_AHB_Slave/software/cmsis/Device/ARM/CMSDK_CM0/Source/ARM/: startup_CMSDK_CM0.s
  group Application
    ./: test.c
  group System
    D:/OneDrive/OneDrive - Singapore University of Technology and Design/SUTD_Study/Y3T6-GEXP/EECE490_Embedded_SOC/EECE490E_Lab/D07_Q_project_AHB_Slave/software/cmsis/Device/ARM/CMSDK_CM0/Source/: system_CMSDK_CM0.c
